# Keil uVision project lE1.uvproj, settings and files
target lE1 (MCS-51)
  device: nRF24LE1 Nordic Semiconductor
  cpu: IRAM(0-0xFF) IROM(0-0x3FFF) XRAM(0x0000-0x03FF) XRAM2(0xFA00-0xFFFF) CLOCK(24000000) MODC2 MDU_R515
  output: lE1 +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: D:\Programas\Nordic Semiconductor\nRFgo SDK 2.3.0.10040\source_code\hal;D:\Programas\Nordic Semiconductor\nRFgo SDK 2.3.0.10040\source_code\compiler\common;D:\Programas\Nordic Semiconductor\nRFgo SDK 2.3.0.10040\source_code\hal\nrf24le1;..\..\nrf24le1\nRF24LE1\libraries
  group App
    ./: lE1.c
  group Hal
    D:/Programas/Nordic Semiconductor/nRFgo SDK 2.3.0.10040/source_code/hal/: hal_delay.c
